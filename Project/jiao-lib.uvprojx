# Keil uVision project jiao-lib.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: jiaoOS +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\led;..\User\usart;..\User\lcd;..\User\flash;..\User\font;..\OS\desktop;..\OS;..\User\TIM;..\OS\DataStructure;..\OS\sheet
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_usart.c
    ../User/lcd/: bsp_xpt2046_lcd.c bsp_ili9341_lcd.c
    ../User/font/: fonts.c
    ../User/flash/: bsp_spi_flash.c
    ../User/TIM/: bsp_base_tim.c
    ../User/Key/: bsp_key.c
  group DOC
    ../Doc/: readme.txt
  group XvSenfengOS
    ../OS/desktop/: jiao_dasktop.c
    ../OS/: jiao_os.c jiao_list.c jiaoConfig.h
    ../OS/DataStructure/: jiao_FIFO.c
    ../OS/sheet/: jiao_sheet.c
    ../OS/task/: jiao_task.c
    ../OS/time/: jiao_time.c
